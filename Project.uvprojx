# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\App;.\Algo;.\Hal;.\Drv;.\Library;.\Hardware;.\ThirdParty\u8g2\csrc;.\ThirdParty\ChibiOS\os\license;.\ThirdParty\ChibiOS\os\common\startup\ARMCMx\devices\STM32F1xx;.\ThirdParty\ChibiOS\os\common\portability\Keil;.\ThirdParty\ChibiOS\os\common\ports\ARM-common\include;.\ThirdParty\ChibiOS\os\common\ports\ARMv7-M;.\ThirdParty\ChibiOS\os\rt\include;.\ThirdParty\ChibiOS\os\oslib\include;.\ThirdParty\ChibiOS\os\hal\ports\common\ARMCMx
  asm misc: --cpreproc
  asm include: .\User;.\Start;.\ThirdParty\ChibiOS\os\license;.\ThirdParty\ChibiOS\os\common\startup\ARMCMx\devices\STM32F1xx;.\ThirdParty\ChibiOS\os\common\ports\ARMv7-M;.\ThirdParty\ChibiOS\os\hal\ports\common\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h chibios_port.c chconf.h board.h stm32f1xx.h
  group App
    ./App/: app_main.c app_main.h app_types.h app_fastloop.c app_fastloop.h app_task_control.c app_task_control.h app_task_ui.c app_task_ui.h app_task_calib.c app_task_calib.h app_menu.c app_menu.h app_task_comm.c app_task_comm.h app_state_machine.c app_state_machine.h app_fault_mgr.c app_fault_mgr.h app_calib.c app_calib.h
  group Algo
    ./Algo/: algo_foc.c algo_foc.h algo_motor_types.h algo_pid.c algo_pid.h algo_limit.c algo_limit.h algo_ramp.c algo_ramp.h algo_observer.c algo_observer.h algo_angle.c algo_angle.h
  group Hal
    ./Hal/: hal_oled_if.c hal_oled_if.h hal_motor_if.c hal_motor_if.h hal_sense_if.c hal_sense_if.h hal_board.c hal_board.h hal_gate_if.c hal_gate_if.h hal_uart_if.c hal_uart_if.h hal_keys_if.c hal_keys_if.h hal_encoder_if.c hal_encoder_if.h
  group Drv
    ./Drv/: drv_adc1.c drv_adc1.h drv_tim1_pwm.c drv_tim1_pwm.h drv_irq.c drv_irq.h drv_gpio.c drv_gpio.h drv_keys.c drv_keys.h drv_usart1.c drv_usart1.h drv_oled_u8g2_port.c drv_oled_u8g2_port.h drv_oled_u8g2_setup.c drv_oled_u8g2_display.c drv_oled_u8g2_display.h drv_mt6816.c drv_mt6816.h drv_flash_cfg.c drv_flash_cfg.h
  group ChibiOS Port
    ./ThirdParty/ChibiOS/os/common/ports/ARMv7-M/: chcore.c
    ./ThirdParty/ChibiOS/os/common/ports/ARMv7-M/compilers/RVCT/: chcoreasm.s
  group ChibiOS Kernel
    ./ThirdParty/ChibiOS/os/rt/src/: chsys.c chsafety.c chrfcu.c chdebug.c chtrace.c chvt.c chschd.c chinstances.c chthreads.c chtm.c chstats.c chregistry.c chsem.c chmtx.c chcond.c chevents.c chmsg.c chdynamic.c
    ./ThirdParty/ChibiOS/os/oslib/src/: chmemchecks.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chpipes.c chobjcaches.c chdelegates.c chfactory.c
  group u8g2
    ./ThirdParty/u8g2/csrc/: u8g2_setup.c u8g2_buffer.c u8g2_cleardisplay.c u8g2_box.c u8g2_circle.c u8g2_font.c u8g2_kerning.c u8g2_hvline.c u8g2_intersection.c u8g2_ll_hvline.c u8x8_setup.c u8x8_display.c u8x8_cad.c u8x8_byte.c u8x8_8x8.c u8x8_capture.c u8x8_u16toa.c u8x8_gpio.c u8x8_d_ssd1306_64x32.c
    ./ThirdParty/u8g2/: u8g2_fonts_subset.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Config.h OLED_Port.h OLED_Port.c OLED_Data.h OLED_Data.c
